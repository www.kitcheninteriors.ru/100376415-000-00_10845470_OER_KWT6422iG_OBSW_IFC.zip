Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-10-14T14:44:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 14 14:44:53 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{E821E530-44DF-4DBC-AA82-8CF37C3C749F}\ifc * Database version: 5507 * Database creation date: Thu Oct 14 14:44:52 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 14 14:44:52 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 14 14:44:52 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 36642220_OER_10845470_KWT6422iG_OBSW, 10845470_OER_KWT6422iG_OBSW:36642220_OER_10845470_KWT6422iG_OBSW:213151
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Alusilver, Default New Material, Poche, z_Miele_Design_Glass, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 36642220_OER_10845470_KWT6422iG_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
